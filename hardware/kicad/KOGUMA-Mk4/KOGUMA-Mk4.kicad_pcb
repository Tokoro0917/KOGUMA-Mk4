# Repository Tokoro0917/KOGUMA-Mk4

## KiCad design hardware/kicad/KOGUMA-Mk4/KOGUMA-Mk4.kicad_pcb

File hardware/kicad/KOGUMA-Mk4/README.md (part):

# KOGUMA-Mk4 の KiCad プロジェクト

KiCad 9.0 で開く(`KOGUMA-Mk4.kicad_pro`)。

| ファイル | 中身 |
|---|---|
| `KOGUMA-Mk4.kicad_sch` | 一番上のシート。下のシートを並べる |
| `power.kicad_sch` | 電源(電池 → 電源スイッチ → VBAT → 3.3V、電池の電圧の分圧) |
| `motor.kicad_sch` | モーター(MP6551 × 2、CM の分圧とコンデンサ)と吸引ファン(IRLML6344、0.1Ω のシャント) |
| `sensor.kicad_sch` | センサ(A3): 壁センサの発光 4ch(OPV332 + NJU6080)、受光 4ch(SFH 229 FA + OPA2354、820kΩ ∥ 0.5pF)、PD_BIAS、IMU(LSM6DSR)、エンコーダの基板(MT6835)とのつなぎ(J5・J6、メイン基板の穴とパッド7つ) |
| `ui.kicad_sch` | 表示・入力・通信: LED 7個と前の LED(D98、PB3)、ブザー、スイッチ、デバッグの端子(J7、ToraNeko.Mk3 の J6 と同じ並び)、UART_RX のテストパッド |
| `mcu.kicad_sch` | MCU(STM32H725RGVx)、SMPS(Direct SMPS)、発振子(10MHz、CSTNE10M0G52Z000R0)、パスコン、BOOT0・NRST。ピンは `docs/pinmap.md` のネット名のグローバルラベルでほかのシートとつなぐ |
| `KOGUMA-Mk4.kicad_sym` | このプロジェクト用の記号: AO4407A、LXDC55FAAA-203、MP6551GQB、IRLML6344、NJU6080、OPA2354、LSM6DSR(標準の LSM6DS3 を写し、SDX を passive に)、STM32H725RGVx(標準の記号を写し、VLXSMPS を power_out、VCAP の49・66番を passive に直した)、片方向のTVS(D_TVS_Uni)、電源記号 VBAT |
| `KOGUMA-Mk4.pretty/` | このプロジェクト用のフットプリント: LXDC55FAAA-203(村田のデータシートの「Reference Land Pattern」)、MPS_QFN-14_2.5x3mm(MP6551 のデータシートの「Recommended Land Pattern」)、Resonator_Murata_CSTNE-3Pin_3.2x1.3mm(村田の仕様書 JGC42-8974A の推奨ランド)、SW_Slide_SPDT_Alps_SSSS8(SW1、SSSS810701。Alps の製品ページの Land Dimensions)、SW_Push_Jianfu_TVAF06(SW2、TVAF06-A020B-R。仕様書の P.C.B LAND DIMENSION)、Buzzer_PUI_SMT-0540(BZ1、SMT-0540-S-R。データシートの Suggested Land Pattern。1 が +、2 が −、番号なしはダミーの足)。この3つは `gen_footprints.py` で作る(2026-10-31)。ENC_Base_Butt(エンコーダの基板 v2 を突き当てる、裏の面のパッド7つ × 2列(エンコーダ基板の内側と外側。両面ではんだ付け)。穴はなし。左の J5 は回転 0°、右の J6 は 180°。`../KOGUMA-Mk4_Encoder/gen_encoder.py` で作る。2026-11-02 までは穴 NPTH 1.0 × 5.9mm の ENC_Base_Slot)、WallSensor_Holder_Emitter・WallSensor_Holder_Receiver(壁センサのホルダの発光・受光の足の穴。Emitter にホルダのほぞの穴(Edge.Cuts)を含む。原点はホルダの前の面の真ん中、光は +X。ホルダは基板の裏に付けるので、同じセンサの2つを**裏の面に**、同じ位置・同じ向きに置く。位置は `mechanical/vehicle/pcb_shape.py` の `SENS`) |
| `KOGUMA-Mk4.kicad_pcb` | **メイン基板**(2026-10-31 に起こした。2層、0.6mm)。`gen_pcb.py` で回路図から作った: 外形は `mechanical/vehicle/pcb_shape.py` の v16、位置が決まっている部品(壁センサ・エンコーダの穴・LED 8個・マウントの柱の穴 H1〜H4)だけ置き、ほかは基板の右の外にシートごとに並べてある。**ここから手で配置・配線する**(`gen_pcb.py` を走らせ直すと上書きされる) |
| `KOGUMA-Mk4.kicad_dru` | 細かいピッチの IC(U4・U74・U75・U76)のパッドの間だけ 0.14mm まで許す(ToraNeko.Mk3 と同じ考え方)。ほかはネットクラスの 0.2mm |
| `place_pcb.py` | 最初の配置(2026-10-31)。IC・コネクタはまとまりごとに位置を決め、抵抗・コンデンサはつながる IC のパッドのそばの空いている所を探して置く |
| `place_caps.py` | IC のまわりにコンデンサと抵抗(とノイズに効く小さな部品)を置き、IC ごとのグループにして基板の外に並べる(2026-11-06)。`gen_pcb.py` のあとに使う |
| `gen_pcb.py`・`gen_footprints.py` | 基板を起こすスクリプト、手で寸法を入れるフットプリント(SW1・SW2・BZ1)を作るスクリプト |
| `sym-lib-table`・`fp-lib-table` | 上の2つをプロジェクトのライブラリとして登録する |

## ネットの名前

| ネット | 中身 |
|---|---|
| `BAT+` | 電池の+(電源スイッチの前。電源のシートの中だけ) |
| `VBAT` | 電源スイッチのあと。MP6551・LXDC55 の入力 |
| `+3V3` | LXDC55 の出力 |
| `+3V3A` | 受光アンプ(U74・U75)と PD_BIAS(R78)の電源。+3V3 から FB2 + C85(2026-11-01) |
| `PGND` | 大きい電流の戻り: 電池の −、VBAT の大きいコンデンサ・TVS、DC-DC、モータードライバの GND・SR、ファンのシャント。GND とはネットタイ NT1 の1か所だけでつなぐ(2026-11-01) |
| `BATT` | 電池の電圧の分圧(MCU の PB1、ADC2_INP5 へ)。グローバルラベル |
| `MOT_L_IN1`・`MOT_L_IN2`・`MOT_R_IN1`・`MOT_R_IN2` | MP6551 の IN(TIM1 の CH1〜CH4) |
| `MOT_EN` | 2個の MP6551 の EN1・EN2(共通) |
| `MOT_nFAULT` | 2個の nFAULT(オープンドレインを共通に、10kΩ で 3.3V へ) |
| `MOT_L_CM1`・`MOT_L_CM2`・`MOT_R_CM1`・`MOT_R_CM2` | CM の電圧(ADC2) |
| `FAN_PWM`・`FAN_ISENSE` | ファンの PWM(TIM16)と電流(ADC1) |
| `WALL_FL`・`WALL_L`・`WALL_R`・`WALL_FR` | 壁センサの受光のアンプの出力(ADC1) |
| `WALL_LED_FL_R`・`WALL_LED_L_FR` | 壁センサの発光(対角の2個ずつ。MK3 の WallLED_12 / WallLED_34) |
| `IMU_*`・`ENC_*` | IMU(SPI3)とエンコーダ(SPI2) |
| `ENC_CAL` | 2個の MT6835 の CAL_EN(左右共通、PC15)。校正のときだけ H |

## 品番(2026-11-01 に決めたもの)

| 部品 | 品番 |
|---|---|
| FB1・FB2 | 村田 BLM18PG221SN1D |
| C4 | KEMET T521V476M025ATE040(ポリマータンタル 47µF 25V、高さ 2.0mm) |
| D40 | onsemi MBR230LSFT1G(30V 2A、SOD-123FL) |
| R41 | 100Ω |
| R21・R31 | 0Ω(実機でノイズを見て上げる) |
| D90〜D96・D98・D2 | Kingbright APTD1608LSECK/J4-PF(オレンジ 605nm、小電流用) |

## 配線の注意(2026-11-06)

回路図のレビューとノイズの評価で出た注意は `docs/review_2026-11-06.md` の「配線の注意」にまとめた。特に: NT1 は C7・C8 の GND のパッドに置き、モーター・ファンの戻りがその間を通らないようにする。VBAT・PGND の幹は 6A で約 2.5mm 以上、モーターの出力は約 1mm 以上(ネットクラスの 0.5mm・0.4mm はパッドの出口だけ)。Q40・D40・R43・J4・C41・C42 は電源のコンデンサ C2〜C4 のそばにまとめる。

## IC ごとのグループ(2026-11-06、`place_caps.py`)

基板に部品を載せる前に、IC とそのコンデンサ・抵抗を、ノイズと線の長さを考えて並べ、**KiCad のグループ**にした(基板の外に17個、基板の上の LED に8個)。グループは基板の外(前の側)にあり、グループごと基板に動かせる(グループの中の部品は、ダブルクリックでグループに入って動かせる)。

置き方:
- コンデンサは、つなぐピンのパッドの外に置き、**そのピンのネットのパッドを IC に向けた**(線を最短に)。もう一方(GND・PGND)のパッドは外を向くので、そこに GND のビアを打つ(電流の輪が小さくなる)
- 小さい値(100nF、220pF)を先に、ピンのいちばん近くに。大きい値(4.7〜22µF)はその外か横
- 部品の外形(コートヤード)は重ねない(DRC で確かめた)

| グループ | 中身(IC のピン) |
|---|---|
| U4 MCU | 抵抗: R50(BOOT0)、R40(nFAULT)、R81・R82(壁センサの発光のプルダウン)、R83・R84(エンコーダの CS)、R4・R5(電池の分圧)・R44(ファンの RC)・R22〜R25・R32〜R35(モーターの CM の VREF・RREF)を、それぞれの MCU のピンのそばに。コンデンサ: Y1 発振子(PH0・PH1、2.4mm)、C53 220pF(VLXSMPS 5)・L1、C50 10µF(VDDSMPS 6)、C54 10µF(VFBSMPS 7)、C57〜C61 100nF(VDD 9・22・35・51・68)、C55・C56 100nF(VCAP 33・49)、C52 100nF・C51 4.7µF・FB1・R51(VDDA 16)、C64(VBAT 1)、C63(NRST)、C62 4.7µF、ADC のフィルタ C9・C40・C23・C24・C33・C34(それぞれの ADC のピン) |
| U1 DC-DC | C6 100nF・C5 10µF(VIN)、C7・C8 22µF(VOUT)、R3(FB)、**NT1(C7 の PGND のパッドのとなり)** |
| U2・U3 MP6551 | C21・C31 100nF と C22・C32 10µF(VIN 2番)、R21・R31(SR) |
| U74・U75 受光アンプ | C83・C84 100nF と C78・C79 10µF(V+ 8番)、帰還の 820k・0.5pF(出力と − 入力の間に、辺に沿って)。U74 に PD_BIAS(C80・R78・R79) |
| U70〜U73 NJU6080 | 100nF(VDD 6番)、Rs(3番) |
| U76 IMU | C81(VDDIO)、C82(VDD) |
| Q1 電源スイッチ | C1・C10・R1・R2(ゲート)、D1 TVS、C2・C3 22µF・C4 47µF(VBAT) |
| Q40 ファン | R43(ソース)、R41・R42(ゲート)、D40・J4、C41 10µF・C42 100nF(J4 のそば) |
| BZ1 ブザー | C91 10µF、D97、Q90、R97(ゲートのプルダウン) |
| SW2 スイッチ | C90、R98(プルアップ) |
| FB2 +3V3A のフィルタ | FB2、R80 2.2Ω、C85 10µF(DC-DC の出力のそばに置く) |
| D2 電源の LED | D2、R6 |
| D90〜D96・D98 LED(基板の上) | LED と抵抗 R90〜R96・R99。抵抗は LED のパッドから 1.7mm、基板の外形の 0.3mm 内側で、電池のホルダの載る所を避けた |

- エンコーダ基板のパスコン C86・C87 は、基板の上の J5・J6 の内側の列の 3.3V と GND のパッドの真上に横向きに置いた(機体の |y| 18.6。電池のホルダの壁から 0.57mm)。それぞれのパッドの上からビアで裏の J5・J6 へ
- グループに入れなかった部品(コネクタ J1・J2・J3・J7、スライドスイッチ SW1、テストパッド TP1 の6個)は、グループの右に並べてある
- 部品の番号・値の文字(シルク)の重なりの警告が出るが、基板に置いてから直す
- 作り直すとき: `python3 gen_pcb.py`(プロジェクトの設定を書き直すので、あとで `git checkout KOGUMA-Mk4.kicad_pro`)→ `python3 place_caps.py`

## まだ決めていないこと

- J1(BT2.0 のケーブルをはんだ付けするパッド)のフットプリント。仮に `Connector_Wire:SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm`
- LXDC55 のフットプリントは、データシートのランドパターンの寸法から作った。基板を注文する前に、実物か村田の最新の資料で確かめる
- **MP6551 のフットプリント(MPS_QFN-14_2.5x3mm)は寸法の読み取りに自信がない**。データシートの図の「2.80」を上下の小さいパッドの中心の間、「1.20」を長いパッドの長さ、「1.30」を中心から長いパッドの外の端までと読んだ(パッケージの足の位置とつじつまが合う読み方)。長いパッドの幅は 0.25mm と仮定。基板を注文する前に、印刷した図に実物を重ねるなどして確かめる
- モーター・ファンの線のパッド(J2〜J4)
- R21・R31(MP6551 の SR)は 0Ω で始める。MP6551 のデータシートで SR の抵抗と立ち上がりの時間の関係を確かめる
- MCU のフットプリントは標準の `Package_DFN_QFN:QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm`(KiCad の記号の既定)。ST のデータシートの図75と見比べる
- 2026-10-31: MP6551(MPS)と STM32H725(ST)のデータシートを取りに行ったが、どちらのサイトも自動の取得を受け付けなかった(MPS はボット対策、ST は接続を切る)。PDF を手で落として渡せば、この2つのフットプリントを図と照らし合わせる

## メイン基板(2026-10-31、2026-11-01 にリセット)

- **2026-11-01: 配置と配線を戻した**(ユーザーが自分で引く)。`gen_pcb.py` で回路図から作り直し、位置が決まっている部品(壁センサ・LED・エンコーダの穴・柱の穴)だけ置いてある。ほかの部品は基板の外。ネットクラスは Default 0.15mm(クリアランス 0.15mm。MCU の QFN-68 のピンから線を出すため)、Battery(BAT+・VBAT・PGND)0.5mm、Motor 0.4mm
- 下の「部品の配置」「配線」は、そのとき試したことの記録(`place_pcb.py`・`route_pcb.py` は残してある)

- **2層、0.6mm**(ToraNeko.Mk3 と同じ)。設計ルールもエンコーダの基板・ToraNeko と同じ: クリアランス 0.2mm、線 0.2mm(最小 0.15)、ビア 0.6/0.3mm、穴と穴 0.25mm、縁まで 0.2mm
- 座標: 機体の座標(原点は車軸の中心、+x 前、+y 左)の (x, y) を KiCad の (150 + x, 100 − y) に置く。上から見て前が右
- 壁センサ: 発光 D70〜D73 と受光 D74〜D77 を**裏の面**に、`pcb_shape.SENS` の位置・向きで置いた(足の穴の位置を `pcb_shape.pads()` と、ほぞの穴を `pcb_shape.slot()` と照らし合わせた)
- エンコーダの基板を突き当てる所: 左 J5(0°)、右 J6(180°)。真ん中 (0, ±20.7)。2026-11-02 から穴はなく、裏のパッド7つ × 2列(`ENC_Base_Butt`)
- **UI の LED**: 後ろの左右の角の4個が**ナンバー**(左の外から NUM3・NUM2、右の内から NUM1・NUM0。後ろから見て左が上の桁)、V 字の先の3個が**モード**(左から MODE2・MODE1・MODE0)、前の LED は (35.2, 0)。1608 なので長い方を前後に向けた(1.9mm おきに並べると、長い方を左右に向けては重なる)
- マウントの柱の穴 H1〜H4(M2、φ2.2、基板だけの部品)
- DRC(回路図との照合つき): **エラーは、まだ置いていない部品のシルクの重なり(基板の外)と、右の外の角の LED のシルクが縁にかかる所だけ**。回路図と基板の食い違い 0。つながっていないパッド 348(配線はこれから)

Notes on the sheet:
シート: 電源・モーター・MCU・センサ・表示と通信

Parts:
C1: 220n 25V; C_0603_1608Metric
C2, C3: 22u 25V; C_1206_3216Metric
C4: T521V476M025ATE040 (47u 25V); CP_EIA-7343-20_Kemet-V
C5: 10u 25V; C_0805_2012Metric
C6: 100n 25V; C_0603_1608Metric
C7, C8: 22u 10V; C_0805_2012Metric
C9: 10n; C_0603_1608Metric
C10: 22n 50V; C_0603_1608Metric
D1: SMF13A; D_SMF
D2: APTD1608LSECK/J4-PF (POWER); LED_0603_1608Metric
J1: BATT (BT2.0); SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1: AO4407A; SOIC-8_3.9x4.9mm_P1.27mm
R1: 100k; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R3: 1.30k 1%; R_0603_1608Metric
R4: 47k 1%; R_0603_1608Metric
R5: 10k 1%; R_0603_1608Metric
R6: 4.7k; R_0603_1608Metric
SW1: SSSS810701; SW_Slide_SPDT_Alps_SSSS8
U1: LXDC55FAAA-203

Connections:
+3V3: C7.1, C8.1, R6.1, U1.7 (VOUT(7,8,9)), U1.8 (VOUT(7,8,9)), U1.9 (VOUT(7,8,9)); also elsewhere on the board
/電源/BAT+: C1.2, J1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.2
/電源/GATE: C1.1, C10.2, Q1.4 (G), R1.1, R2.1
BATT: C9.1, R4.2, R5.1; also elsewhere on the board
GND: C9.2, NT1.2, R5.2, SW1.2 (B); also elsewhere on the board
unnamed: D2.2 (A), R6.2
unnamed: R2.2, SW1.1 (A)
unnamed: R3.1, U1.11 (FB(11))
PGND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.2 (A), D2.1 (K), J1.2, NT1.1, R3.2, U1.6 (GND(6,12,13,14)), U1.12 (GND(6,12,13,14)), U1.13 (GND(6,12,13,14)), U1.14 (GND(6,12,13,14)); also elsewhere on the board
VBAT: C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, D1.1 (K), Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), R4.1, U1.1 (EN(1)), U1.3 (VIN(3,4,5)), U1.4 (VIN(3,4,5)), U1.5 (VIN(3,4,5)); also elsewhere on the board

Notes on the sheet:
電源(電池 → 電源スイッチ → VBAT → 3.3V)
電池: 1S 180mAh × 3 を電池の側で直列(3S、満充電12.6V)。BT2.0 のケーブルを J1 のパッドにはんだ付けする。 Q1: SW1 で GATE を R2 を通して GND に落とすと ON(VGS = −VBAT × R1/(R1+R2))。 C1 と R1∥R2(約9.1kΩ)で約1ms かけて ON になる(電源を入れた瞬間の跳ね上がりを抑える)。OFF は R1 × C1 で約10ms。
D1・C2〜C4: VBAT の跳ね上がりとPWMのリップルを抑える。C4 はポリマー(ESRで振動を止める)。 MP6551 の VIN のパスコン(100n + 10u)はモーターのシートに置く。
3.3V: RFB = 7.29 / (Vout − 0.8) − 1.6 [kΩ]、1.30kΩ で約3.31V。 Cout は 22〜150µF(データシート)。EN は VBAT につなぐ(常に ON)。PG は使わない。
R4・R5・C9: 分圧は MP6551 の VIN の近くから取る。 12.6V で約2.2V。止める電圧 11.3V はソフトで判断する。
SW1・J1 のフットプリントは未作成(SSSS810701、BT2.0 の線の太さで決める)
GND の分け方(2026-11-01、MK3 で吸引・車輪の PWM の電流が壁センサ FL・L にのったため): PGND = 電池の −、VBAT の大きいコンデンサ・TVS、DC-DC(LXDC55)と入出力のコンデンサ、モータードライバの GND・SR、ファンのシャント。 GND(信号)とは NT1 の1か所だけでつなぐ。NT1 は DC-DC の出力のコンデンサの GND のそばに置き、大きい電流が信号の GND を流れないようにする
ソフトスタート(2026-11-06): C10(ゲートとドレイン)+ C1 220n(ゲートとソース)。 ON まで約0.75ms、VBAT の立ち上がり約0.3ms、突入約3A。C1:C10 = 10:1 で、電池を挿したときに勝手に ON しない

Parts:
C21, C31, C42: 100n 25V; C_0603_1608Metric
C22, C32, C41: 10u 25V; C_0805_2012Metric
C23, C24, C33, C34: 1n; C_0603_1608Metric
C40: 1u; C_0603_1608Metric
D40: MBR230LSFT1G; D_SOD-123F
J2: MOTOR_L; SolderWire-0.25sqmm_1x02_P4.2mm_D0.65mm_OD1.7mm
J3: MOTOR_R; SolderWire-0.25sqmm_1x02_P4.2mm_D0.65mm_OD1.7mm
J4: FAN; SolderWire-0.25sqmm_1x02_P4.2mm_D0.65mm_OD1.7mm
Q40: IRLML6344; SOT-23
R21, R31: 0; R_0603_1608Metric
R22, R23, R24, R25, R32, R33, R34, R35: 4.7k 1%; R_0603_1608Metric
R40, R42: 10k; R_0603_1608Metric
R41: 100; R_0603_1608Metric
R43: 0.1 1W; R_2512_6332Metric
R44: 1k; R_0603_1608Metric
U2, U3: MP6551GQB; MPS_QFN-14_2.5x3mm

Connections:
+3V3: R22.1, R24.1, R32.1, R34.1, R40.1; also elsewhere on the board
/モーター/FAN_SRC: Q40.2 (S), R42.2, R43.1, R44.1
FAN_ISENSE: C40.1, R44.2; also elsewhere on the board
FAN_PWM: R41.1; also elsewhere on the board
GND: C23.2, C24.2, C33.2, C34.2, C40.2, R23.2, R25.2, R33.2, R35.2; also elsewhere on the board
MOT_EN: U2.4 (EN2(4)), U2.14 (EN1(14)), U3.4 (EN2(4)), U3.14 (EN1(14)); also elsewhere on the board
MOT_L_CM1: C23.1, R22.2, R23.1, U2.11 (CM1(11)); also elsewhere on the board
MOT_L_CM2: C24.1, R24.2, R25.1, U2.7 (CM2(7)); also elsewhere on the board
MOT_L_IN1: U2.13 (IN1(13)); also elsewhere on the board
MOT_L_IN2: U2.5 (IN2(5)); also elsewhere on the board
MOT_R_CM1: C33.1, R32.2, R33.1, U3.11 (CM1(11)); also elsewhere on the board
MOT_R_CM2: C34.1, R34.2, R35.1, U3.7 (CM2(7)); also elsewhere on the board
MOT_R_IN1: U3.13 (IN1(13)); also elsewhere on the board
MOT_R_IN2: U3.5 (IN2(5)); also elsewhere on the board
MOT_nFAULT: R40.2, U2.12 (nFAULT(12)), U3.12 (nFAULT(12)); also elsewhere on the board
unnamed: D40.2 (A), J4.2, Q40.3 (D)
unnamed: J2.1, U2.1 (OUT1(1,10)), U2.10 (OUT1(1,10))
unnamed: J2.2, U2.3 (OUT2(3,8)), U2.8 (OUT2(3,8))
unnamed: J3.1, U3.1 (OUT1(1,10)), U3.10 (OUT1(1,10))
unnamed: J3.2, U3.3 (OUT2(3,8)), U3.8 (OUT2(3,8))
unnamed: Q40.1 (G), R41.2, R42.1
unnamed: R21.1, U2.6 (SR(6))
unnamed: R31.1, U3.6 (SR(6))
PGND: C21.2, C22.2, C31.2, C32.2, C41.2, C42.2, R21.2, R31.2, R43.2, U2.9 (GND(9)), U3.9 (GND(9)); also elsewhere on the board
VBAT: C21.1, C22.1, C31.1, C32.1, C41.1, C42.1, D40.1 (K), J4.1, U2.2 (VIN(2)), U3.2 (VIN(2)); also elsewhere on the board

Notes on the sheet:
モーター(MP6551 × 2)と吸引ファン
駆動: IN1・IN2 の両方を TIM1 の PWM に。前進は IN1 = PWM・IN2 = 0、後退はその逆。PWM の OFF では両方 L(下側のFETで減衰)。 電流: 0 に固定している側の CM(前進なら CM2)を読む。その下側のFETには ON でも OFF でもモーターの電流が流れる。CM1 と CM2 はつながない。
CM: VOUT = 1.65V + RREF × I / 10,000、RREF = 4.7k ∥ 4.7k = 2.35kΩ。+側 約0.29V/A(約5.4Aまで)、−側 約0.22V/A。 CM の抵抗とコンデンサは MCU の ADC のピンのそばに置く。ADC の基準と同じ 3.3V で分圧する(比で読む)。 比は typ. しかない(+1A で 120〜125µA、−1A で −91〜−95µA)ので、1個ずつ・向きごとに校正する。0A は起動のときに測る。
C21・C22・C31・C32: MP6551 の VIN のそば(100n を一番近くに)。 R21・R31(SR): 0Ω から始め、ノイズを見て上げる(3MΩ で約3µs)。
ファン: VBAT からローサイドで PWM(TIM16)。 R43 の電圧はケルビン接続で取り出し、 R44・C40(約160Hz)で平均して ADC へ。 起動はゆっくり(12.6V/1Ω で最大12.6A流れる)。
モーター・ファンの線を基板にはんだ付けするパッド(J2〜J4)は仮(線の太さで決める)
ファンの VBAT のコンデンサ(2026-11-06): J4 のすぐそばに置く。Q40・D40・R43・J4 は電源のコンデンサ C2〜C4 のそばにまとめる。 R43 の PGND 側は、ほかの電流と共用しない線で NT1 のそばへ(ケルビン接続)。R42 の下の端は Q40 のソース(FAN_SRC)

Parts:
C50: 10u 10V; C_0603_1608Metric
C51, C62: 4.7u 10V; C_0603_1608Metric
C52, C55, C56, C57, C58, C59, C60, C61, C63, C64: 100n; C_0603_1608Metric
C53: 220p; C_0603_1608Metric
C54: 10u; C_0603_1608Metric
FB1: BLM18PG221SN1D; L_0603_1608Metric
L1: 2.2u DFE201610E-2R2M; L_Murata_DFE201610P
R50: 10k; R_0603_1608Metric
R51: 2.2; R_0603_1608Metric
U4: STM32H725RGVx; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm
Y1: CSTNE10M0G52Z000R0; Resonator_Murata_CSTNE-3Pin_3.2x1.3mm

Connections:
+3V3: C50.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C64.1, R51.2, U4.1 (VBAT), U4.6 (VDDSMPS), U4.9 (VDD), U4.22 (VDD), U4.35 (VDD), U4.51 (VDD), U4.68 (VDD); also elsewhere on the board
/MCU/BOOT0: R50.1, U4.63 (BOOT0)
/MCU/OSC_IN: U4.10 (PH0), Y1.1
/MCU/OSC_OUT: U4.11 (PH1), Y1.3
/MCU/VCORE: C54.1, C55.1, C56.1, L1.1, U4.7 (VFBSMPS), U4.33 (VCAP), U4.49 (VCAP), U4.66 (VCAP)
BATT: U4.30 (PB1); also elsewhere on the board
BUZZER: U4.65 (PB9); also elsewhere on the board
ENC_CAL: U4.3 (PC15); also elsewhere on the board
ENC_L_CS: U4.40 (PC6); also elsewhere on the board
ENC_MISO: U4.38 (PB14); also elsewhere on the board
ENC_MOSI: U4.39 (PB15); also elsewhere on the board
ENC_R_CS: U4.41 (PC7); also elsewhere on the board
ENC_SCK: U4.47 (PA12); also elsewhere on the board
FAN_ISENSE: U4.29 (PB0); also elsewhere on the board
FAN_PWM: U4.64 (PB8); also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.1, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, R50.2, U4.4 (VSSSMPS), U4.8 (VSS), U4.15 (VSSA), U4.21 (VSS), U4.34 (VSS), U4.50 (VSS), U4.67 (VSS), U4.69 (VSS), Y1.2; also elsewhere on the board
IMU_CS: U4.53 (PA15(JTDI)); also elsewhere on the board
IMU_INT: U4.57 (PD2); also elsewhere on the board
IMU_MISO: U4.55 (PC11); also elsewhere on the board
IMU_MOSI: U4.56 (PC12); also elsewhere on the board
IMU_SCK: U4.54 (PC10); also elsewhere on the board
LED_FRONT: U4.58 (PB3(JTDO); also elsewhere on the board
LED_MODE0: U4.17 (PA0); also elsewhere on the board
LED_MODE1: U4.18 (PA1); also elsewhere on the board
LED_MODE2: U4.19 (PA2); also elsewhere on the board
LED_NUM0: U4.20 (PA3); also elsewhere on the board
LED_NUM1: U4.32 (PB10); also elsewhere on the board
LED_NUM2: U4.36 (PB12); also elsewhere on the board
LED_NUM3: U4.37 (PB13); also elsewhere on the board
MOT_EN: U4.31 (PB2); also elsewhere on the board
MOT_L_CM1: U4.27 (PC4); also elsewhere on the board
MOT_L_CM2: U4.28 (PC5); also elsewhere on the board
MOT_L_IN1: U4.43 (PA8); also elsewhere on the board
MOT_L_IN2: U4.44 (PA9); also elsewhere on the board
MOT_R_CM1: U4.23 (PA4); also elsewhere on the board
MOT_R_CM2: U4.24 (PA5); also elsewhere on the board
MOT_R_IN1: U4.45 (PA10); also elsewhere on the board
MOT_R_IN2: U4.46 (PA11); also elsewhere on the board
MOT_nFAULT: U4.42 (PC9); also elsewhere on the board
NRST: C63.1, U4.12 (NRST); also elsewhere on the board
unnamed: FB1.2, R51.1
unnamed: C51.1, C52.1, FB1.1, U4.16 (VDDA)
unnamed: C53.2, L1.2, U4.5 (VLXSMPS)
SW: U4.2 (PC14); also elsewhere on the board
SWCLK: U4.52 (PA14(JTCK); also elsewhere on the board
SWDIO: U4.48 (PA13(JTMS); also elsewhere on the board
UART_RX: U4.62 (PB7); also elsewhere on the board
UART_TX: U4.61 (PB6); also elsewhere on the board
WALL_FL: U4.13 (PC0); also elsewhere on the board
WALL_FR: U4.26 (PA7); also elsewhere on the board
WALL_L: U4.14 (PC1); also elsewhere on the board
WALL_LED_FL_R: U4.59 (PB4(NJTRST)); also elsewhere on the board
WALL_LED_L_FR: U4.60 (PB5); also elsewhere on the board
WALL_R: U4.25 (PA6); also elsewhere on the board

Notes on the sheet:
HSE: 村田のセラミック発振子 CSTNE10M0G52Z000R0(10MHz、MK3 と同じ)。負荷容量 10pF が中に入っているので外付けのコンデンサは要らない。 精度 ±0.5%(出荷時)+ ±0.2%(温度)。Y1 は PH0・PH1 のすぐそばに置く。
MCU(STM32H725RGVx、VFQFPN68)
ピンの割り当ては docs/pinmap.md。ラベルはほかのシートとつながる(MCU から見た向き)。PC15 はエンコーダの校正(ENC_CAL)。PD2 は IMU の INT1(IMU_INT)、PB3 は前の LED(LED_FRONT)(2026-10-31)。PB3 は JTDO なので、CubeMX でデバッグを Serial Wire にして GPIO で使う。PH0・PH1 は水晶(HSE)。
SMPS(Direct SMPS supply、DS13311 の図17・表16): VLXSMPS → L1(2.2µH)→ VCORE。VFBSMPS と VCAP × 3 は VCORE につなぐ。 C54 は VFBSMPS の出力のコンデンサ(10µF、ESR 20mΩ 以下)、C53 は VLXSMPS の 220pF。 VCAP は表15の注に従い 100nF × 2(レギュレータを使わないとき。2.2µF は要らない)。3本目の VCAP はつなぐだけ。 L1・C53・C54 は VLXSMPS・VFBSMPS のすぐそばに置き、壁センサのアンプと ADC の入力から離す。
パスコン: VDD のピンごとに 100nF(C57〜C61)+ 4.7µF(C62)。VBAT は VDD につなぎ、100nF(C64)。 VDDA は FB1 と 1µF + 100nF(ADC の基準も VDDA)。C54 は ESR 20mΩ 以下。
BOOT0: 10kΩ で GND(内蔵Flashから起動)。 NRST: 100nF。SWD の端子にも出す。

Parts:
C70, C71, C72, C73, C81, C82, C83, C84: 100n; C_0603_1608Metric
C74, C75, C76, C77: 0.5p C0G; C_0603_1608Metric
C78, C79, C80, C85: 10u; C_0603_1608Metric
C86, C87: 2.2u 10V; C_0603_1608Metric
D70: OPV332 (FL); WallSensor_Holder_Emitter
D71: OPV332 (L); WallSensor_Holder_Emitter
D72: OPV332 (R); WallSensor_Holder_Emitter
D73: OPV332 (FR); WallSensor_Holder_Emitter
D74: SFH 229 FA (FL); WallSensor_Holder_Receiver
D75: SFH 229 FA (R); WallSensor_Holder_Receiver
D76: SFH 229 FA (FR); WallSensor_Holder_Receiver
D77: SFH 229 FA (L); WallSensor_Holder_Receiver
FB2: BLM18PG221SN1D; L_0603_1608Metric
J5: ENC_L; ENC_Base_Butt
J6: ENC_R; ENC_Base_Butt
R70, R71, R72, R73: 20 1%; R_0603_1608Metric
R74, R75, R76, R77: 820k; R_0603_1608Metric
R78: 1k; R_0603_1608Metric
R79: 47; R_0603_1608Metric
R80: 2.2; R_0603_1608Metric
R81: 4.7k; R_0603_1608Metric
R82: 47k; R_0603_1608Metric
R83, R84: 10k; R_0603_1608Metric
U70, U71, U72, U73: NJU6080; SOT-23-6
U74, U75: OPA2354; VSSOP-8_3x3mm_P0.65mm
U76: LSM6DSR; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y

Connections:
+3V3: C70.1, C71.1, C72.1, C73.1, C81.1, C82.1, C86.1, C87.1, D70.2 (A), D71.2 (A), D72.2 (A), D73.2 (A), FB2.1, J5.1, J6.1, R83.1, R84.1, U70.5 (EN), U70.6 (VDD), U71.5 (EN), U71.6 (VDD), U72.5 (EN), U72.6 (VDD), U73.5 (EN), U73.6 (VDD), U76.5 (VDDIO), U76.8 (VDD); also elsewhere on the board
+3V3A: C78.1, C79.1, C83.1, C84.1, C85.1, R78.1, R80.2, U74.8 (V+), U75.8 (V+)
/センサ/PD_BIAS: C80.1, R78.2, R79.1, U74.3 (+), U74.5 (+), U75.3 (+), U75.5 (+)
ENC_CAL: J5.2, J6.2; also elsewhere on the board
ENC_L_CS: J5.6, R83.2; also elsewhere on the board
ENC_MISO: J5.3, J6.3; also elsewhere on the board
ENC_MOSI: J5.4, J6.4; also elsewhere on the board
ENC_R_CS: J6.6, R84.2; also elsewhere on the board
ENC_SCK: J5.5, J6.5; also elsewhere on the board
GND: C70.2, C71.2, C72.2, C73.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, D74.2 (A), D75.2 (A), D76.2 (A), D77.2 (A), J5.7, J6.7, R70.2, R71.2, R72.2, R73.2, R79.2, R81.2, R82.2, U70.2 (GND), U71.2 (GND), U72.2 (GND), U73.2 (GND), U74.4 (V-), U75.4 (V-), U76.2 (SDX), U76.3 (SCX), U76.6 (GND), U76.7 (GND); also elsewhere on the board
IMU_CS: U76.12 (CS); also elsewhere on the board
IMU_INT: U76.4 (INT1); also elsewhere on the board
IMU_MISO: U76.1 (SDO/SA0); also elsewhere on the board
IMU_MOSI: U76.14 (SDA); also elsewhere on the board
IMU_SCK: U76.13 (SCL); also elsewhere on the board
unnamed: D70.1 (K), U70.4 (LED)
unnamed: D71.1 (K), U71.4 (LED)
unnamed: D72.1 (K), U72.4 (LED)
unnamed: D73.1 (K), U73.4 (LED)
unnamed: C74.1, D74.1 (K), R74.1, U74.2 (-)
unnamed: C75.1, D75.1 (K), R75.1, U74.6 (-)
unnamed: C76.1, D76.1 (K), R76.1, U75.2 (-)
unnamed: C77.1, D77.1 (K), R77.1, U75.6 (-)
unnamed: FB2.2, R80.1
unnamed: R70.1, U70.3 (Rs)
unnamed: R71.1, U71.3 (Rs)
unnamed: R72.1, U72.3 (Rs)
unnamed: R73.1, U73.3 (Rs)
WALL_FL: C74.2, R74.2, U74.1; also elsewhere on the board
WALL_FR: C76.2, R76.2, U75.1; also elsewhere on the board
WALL_L: C77.2, R77.2, U75.7; also elsewhere on the board
WALL_LED_FL_R: R81.1, U70.1 (PWM), U72.1 (PWM); also elsewhere on the board
WALL_LED_L_FR: R82.1, U71.1 (PWM), U73.1 (PWM); also elsewhere on the board
WALL_R: C75.2, R75.2, U74.7; also elsewhere on the board

Notes on the sheet:
センサ(壁センサ 4ch、IMU、エンコーダの基板へ)
壁センサの発光: OPV332 を1個ずつ NJU6080(SOT-23-6、VDD 2.5〜5.5V)で 10mA(I = 0.2V / 20Ω)。電源は 3.3V(MK3 は 5V で2個直列)。 MK3 と同じく対角の2個ずつ点ける: WALL_LED_FL_R が FL と R、WALL_LED_L_FR が L と FR(MK3 の WallLED_12 / WallLED_34)。
受光: SFH 229 FA を OPA2354(100MHz)で電流-電圧変換(820kΩ ∥ 0.5pF C0G、帯域 約390kHz、1% まで 約1.9µs)。+ 入力に PD_BIAS(約0.148V)。MK3 は AD8606 + 2.2pF で 約8µs。 0.5pF は浮遊容量が効くので実機で波形を見て決める。アンプとフォトダイオードはモーター・SMPS の電流の通り道から離し、GND は1点でつなぐ。
OPA2354 の電源(100nF + 10µF をすぐそばに)と PD_BIAS(MK3 と同じ)
IMU: LSM6DSR を SPI(SPI3、モード3)で。SDX・SCX は GND。INT1 は MCU の PD2(IMU_INT、データ準備完了の割り込み。2026-10-31)。INT2 はつながない。
エンコーダ: MT6835(TSSOP-16、SPI モード3、最高 約16MHz)を小さな基板(6.0 × 10.3mm、左右で同じ、hardware/kicad/KOGUMA-Mk4_Encoder)に載せる。 エンコーダの基板はメイン基板の裏に突き当て(2026-11-02、穴はなし)、裏のパッド(ENC_Base_Butt、エンコーダ基板の両側に7つずつ)と両面ではんだ付けする(線は使わない)。 ENC_CAL は2個の CAL_EN(左右共通、MCU の PC15)。校正のときだけ H にする。J5 は左、J6 は右(右は 180° 回して置く)。
OPV332・SFH 229 FA はセンサのホルダ(mechanical/sensor_holder、ToraNeko.Mk3 と同じ形)に入れ、基板の裏(下)に付ける。発光が基板から遠い穴、受光が近い穴。 同じセンサの WallSensor_Holder_Emitter と WallSensor_Holder_Receiver は裏の面に、同じ位置・同じ向きに置く。位置と向きは mechanical/vehicle/pcb_shape.py の SENS。
受光アンプ(U74・U75)と PD_BIAS は +3V3A からとる(2026-11-01)。FB2 + C85 で、発光のパルスや MCU の 3.3V の揺れから分ける。 FB2 は 3.3V の DC-DC のそば、C85 は FB2 のすぐあと。+3V3A の線は受光アンプまで GND(信号)に沿わせて引く
リセット中・起動直後のピンの状態(2026-11-06): PB4(WALL_LED_FL_R)は NJTRST で中でプルアップされるので、R81 で下げる(発光が点きっぱなしにならない)。R82 は PB5。 R83・R84 はエンコーダの CS(リセット中に浮かない)。 C86・C87 は J5・J6 のそばに置く(MT6835 は 22mA)
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