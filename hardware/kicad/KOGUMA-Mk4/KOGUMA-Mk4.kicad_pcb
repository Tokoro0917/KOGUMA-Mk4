# Repository Tokoro0917/KOGUMA-Mk4 (continued)

## KiCad design hardware/kicad/KOGUMA-Mk4/KOGUMA-Mk4.kicad_pcb (continued)

Parts:
BZ1: SMT-0540-S-R; Buzzer_PUI_SMT-0540
C90, C92: 100n; C_0603_1608Metric
C91: 10u 10V; C_0603_1608Metric
D90: APTD1608LSECK/J4-PF (MODE0); LED_0603_1608Metric
D91: APTD1608LSECK/J4-PF (MODE1); LED_0603_1608Metric
D92: APTD1608LSECK/J4-PF (MODE2); LED_0603_1608Metric
D93: APTD1608LSECK/J4-PF (NUM0); LED_0603_1608Metric
D94: APTD1608LSECK/J4-PF (NUM1); LED_0603_1608Metric
D95: APTD1608LSECK/J4-PF (NUM2); LED_0603_1608Metric
D96: APTD1608LSECK/J4-PF (NUM3); LED_0603_1608Metric
D97, D99, D100, D101: BAT54WS; D_SOD-323
D98: APTD1608LSECK/J4-PF (FRONT); LED_0603_1608Metric
D110: APTD1608LSECK/J4-PF (WALL_FL); LED_0603_1608Metric
D111: APTD1608LSECK/J4-PF (WALL_L); LED_0603_1608Metric
D112: APTD1608LSECK/J4-PF (WALL_R); LED_0603_1608Metric
D113: APTD1608LSECK/J4-PF (WALL_FR); LED_0603_1608Metric
D114: APTD1608LSECK/J4-PF (STATUS0); LED_0603_1608Metric
D115: APTD1608LSECK/J4-PF (STATUS1); LED_0603_1608Metric
J7: DEBUG (STLINK-V3MODS); PinHeader_2x03_P1.27mm_Vertical
Q90: 2N7002; SOT-23
R90, R91, R92, R93, R94, R95, R96, R99, R110, R111, R112, R113, R114, R115: 1k; R_0603_1608Metric
R97, R98: 10k; R_0603_1608Metric
R101: 4.7k; R_0603_1608Metric
SW2: TS-1088-AR02016; SW_Push_Jianfu_TVAF06
TP1: UART_RX; TestPoint_Pad_D1.0mm
TP2: BLE_SWDIO; TestPoint_Pad_D1.0mm
TP3: BLE_SWDCLK; TestPoint_Pad_D1.0mm
TP4: BOOT0; TestPoint_Pad_D1.0mm
U5: HY0020; FDK_HY0020

Connections:
+3V3: BZ1.1 (+), C91.1, C92.1, D97.1 (K), J7.1, R98.1, R101.1, U5.D1 (VDD); also elsewhere on the board
/表示・通信/BLE_ANT: U5.A3 (ANT), U5.B3 (RFIO)
/表示・通信/BLE_DCC: U5.M1 (DCC), U5.N1 (DEC4)
/表示・通信/BLE_NRST: D101.1 (K), U5.K1 (P0.07)
/表示・通信/BLE_SWDCLK: TP3.1, U5.G4 (SWDCLK)
/表示・通信/BLE_SWDIO: TP2.1, U5.H4 (SWDIO)
/表示・通信/BLE_TX: D99.1 (K), U5.H1 (P0.06)
/表示・通信/UART_RX_W: D100.1 (K), TP1.1
BOOT0: TP4.1; also elsewhere on the board
BUZZER: Q90.1 (G), R97.1; also elsewhere on the board
GND: C90.2, C91.2, C92.2, D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), D98.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), D113.1 (K), D114.1 (K), D115.1 (K), J7.5, Q90.2 (S), R97.2, SW2.2, U5.A2 (VSS1), U5.D3 (VSS2), U5.E1 (VSS6), U5.E4 (VSS3), U5.F4 (VSS4), U5.N4 (VSS5); also elsewhere on the board
LED_FRONT: R99.1; also elsewhere on the board
LED_MODE0: R90.1; also elsewhere on the board
LED_MODE1: R91.1; also elsewhere on the board
LED_MODE2: R92.1; also elsewhere on the board
LED_NUM0: R93.1; also elsewhere on the board
LED_NUM1: R94.1; also elsewhere on the board
LED_NUM2: R95.1; also elsewhere on the board
LED_NUM3: R96.1; also elsewhere on the board
LED_STATUS0: R114.1; also elsewhere on the board
LED_STATUS1: R115.1; also elsewhere on the board
LED_WALL_FL: R110.1; also elsewhere on the board
LED_WALL_FR: R113.1; also elsewhere on the board
LED_WALL_L: R111.1; also elsewhere on the board
LED_WALL_R: R112.1; also elsewhere on the board
NRST: D101.2 (A), J7.3; also elsewhere on the board
unnamed: BZ1.2 (-), D97.2 (A), Q90.3 (D)
unnamed: D90.2 (A), R90.2
unnamed: D91.2 (A), R91.2
unnamed: D92.2 (A), R92.2
unnamed: D93.2 (A), R93.2
unnamed: D94.2 (A), R94.2
unnamed: D95.2 (A), R95.2
unnamed: D96.2 (A), R96.2
unnamed: D98.2 (A), R99.2
unnamed: D110.2 (A), R110.2
unnamed: D111.2 (A), R111.2
unnamed: D112.2 (A), R112.2
unnamed: D113.2 (A), R113.2
unnamed: D114.2 (A), R114.2
unnamed: D115.2 (A), R115.2
SW: C90.1, R98.2, SW2.1; also elsewhere on the board
SWCLK: J7.4; also elsewhere on the board
SWDIO: J7.6; also elsewhere on the board
UART_RX: D99.2 (A), D100.2 (A), R101.2, U5.F1 (P0.04/AIN2); also elsewhere on the board
UART_TX: J7.2, U5.J1 (P0.08); also elsewhere on the board

Notes on the sheet:
表示・入力・通信
LED: GPIO が H で点灯(MK3 と同じ)。1kΩ で 約1mA(3.3V、LED の電圧降下 約2V)。モード3ビット + ナンバー4ビット + 前の LED(D98、PE0。2026-10-31 に PB3、2026-11-26 に PE0)。 2026-11-27(ユーザー): 壁の表示 LED 4個(D110〜D113: FL・L・R・FR のセンサが壁を見ているとき点ける)と状態の LED 2個(D114・D115)を足した。抵抗はどれも 1kΩ。電源の LED は電源のシート。
ブザー: SMT-0540-S-R(定格3V)を 3.3V から 2N7002 で鳴らす(TIM17 の PWM)。 D97 はコイルの逆起電力を逃がす。
スイッチ: 10kΩ で 3.3V に上げ、押すと L(MK3 と同じ)。 C90 はチャタリングを少し減らす(約1ms)。
J7: ToraNeko.Mk3 の J6 と同じ並び(1 3.3V、2 UART_TX、3 NRST、4 SWCLK、5 GND、6 SWDIO、1.27mm 2 × 3)。 STLINK-V3MODS で書き込み・デバッグとログ(仮想COMポート)。UART_RX は TP1(使うときだけ線をつなぐ。D100 を通す)。
SW2・BZ1 のフットプリントは KOGUMA-Mk4.pretty(gen_footprints.py、メーカーの推奨ランド)
ブザーのコンデンサ(2026-11-06): BZ1 のすぐそばに置く。D97 は BAT54WS(200mA)
BLE モジュール HY0020(U5、2026-11-23): ログ・書き込み・パラメータ・ターンの自動調整を無線で(PC と BLE)。 MCU の USART1(PB6・PB7)とつなぐ。P0.06 の送信は D99 で UART_RX を L に引くだけ(有線の TP1 も D100 で同じ。R101 で引き上げ)。P0.04 で UART_RX を見る。P0.07 は D101 で NRST を L に引くだけ(MCU のピンは増えない)。BOOT0 にはつながない(2026-11-23、AN2606: H72x の書き込み用のプログラムの USART1 は PA9・PA10 だけ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
有線と無線をぶつけない(2026-11-23): UART_RX は R101 で引き上げ、送る側(HY0020 の P0.06、TP1 の有線)は それぞれダイオード(D99・D100)で L に引くだけ(ワイヤード AND)。どちらからも送れ、H どうしがぶつからない。 電源を切っているときに有線から MCU に電流が回らない。HY0020 の P0.04 で UART_RX を見て、有線が送っている間は待つ。 NRST は D101 で HY0020 から L に引くだけ(STLINK・MCU の中のリセットとぶつからない)
TP4: BOOT0 のテストパッド(2026-11-23)。ふだんは何もつながない(R50 10kΩ で L)。 電源の設定ミスなどで MCU が応答しなくなったら: TP4 を 3.3V(J7 の1番など)につないだまま電源を入れ、 STLINK でつないで消す(ST の書き込み用のプログラムが動き、自分のプログラムは動かない)

Board: 2 copper layers, 176 parts (8 on the bottom side), 116 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2

## KiCad design hardware/kicad/KOGUMA-Mk4_Encoder_t24/KOGUMA-Mk4_Encoder_t24.kicad_pcb

File hardware/kicad/KOGUMA-Mk4_Encoder_t24/README.md:

# KOGUMA-Mk4_Encoder_t24(タイヤ24mm 用のエンコーダの基板、2026-11-21)

ブランチ `claude/trusting-dirac-1tdt54`(タイヤを MK3 と同じ 24mm にした機体。`docs/spec.md` の「方針の変更(2026-11-21)」)。KiCad 9.0 で開く(`KOGUMA-Mk4_Encoder_t24.kicad_pro`)。左右で同じ基板を2枚使う。

**回路は main の `KOGUMA-Mk4_Encoder` と同じ**(MT6835、C1 0.1µF、J1 のパッド7つ。回路図は J1 のフットプリントだけを `ENC_Edge_T24` にした)。基板は `../make_encoder_t24.py` で、main のプロジェクトを写してから作り直す(`/usr/bin/python3.12 hardware/kicad/make_encoder_t24.py`。Ubuntu 24.04 の KiCad 9 の Python は 3.12 向けで、3.13 では落ちる。作り直すたびに部品とパッドの uuid は変わる)。絵は `python3 hardware/kicad/draw_encoder_t24.py`。

## 置き方

| 項目 | 値 |
|---|---|
| 基板 | **6.0 × 8.75 × 0.6mm**、2層。機体では x −3.0〜3.0、**z 8.15〜16.9**、右は y −17.5〜−16.9 |
| MT6835 | チップの面(F、外側)。中心は x 0、**z 12.0(車軸)**。磁石とのすき間 0.5mm(main と同じ) |
| メイン基板との関係 | メイン基板(z 13.6〜14.2)の切り欠き(x ±4.5、y ±16.7 より外)の縁に沿って、縁から 0.2mm 外に立てる。基板の上に 2.7mm 出る |
| はんだ付け | **J1 のパッド7つは裏の面(B、内側 = メイン基板の側)**、**上の段 z 14.4〜16.0・下の段 z 12.4〜13.4 の2段**。メイン基板が入る所(z 13.6〜14.2)とその上下 0.2mm には銅を出さない(ユーザー: 貫通させない。はんだがメイン基板の縁とのすき間に流れ込むと、エンコーダ基板とメイン基板の距離が変わる)。上の段と下の段はレジストでおおった 0.2mm の線でつなぐ。メイン基板の**上の面のパッドと裏の面のパッド**(`ENC_Base_Edge_T24`)の**どちらとも**直角にはんだ付けできる(片方だけでも、両方でも。2026-11-25、ユーザー)。直角は治具とマウントの面で保つ |
| 左右 | **左右とも同じ基板**。右はこのまま、左は z 軸のまわりに 180° 回して付ける。上・裏のどちらではんだ付けしても同じ基板 |

## J1(裏の面、チップの面から見て左から)

| 基板の真ん中から | −2.4 | −1.6 | −0.8 | 0 | +0.8 | +1.6 | +2.4 |
|---|---|---|---|---|---|---|---|
| ピン | 6 | 5 | 4 | 3 | 2 | 7 | 1 |
| ネット | ENC_CS | ENC_SCK | ENC_MOSI | ENC_MISO | ENC_CAL | GND | +3V3 |

パッドは上の段 0.5 × 1.6mm、下の段 0.5 × 1.0mm(2026-11-25。上の段は 1.8mm から縮めて、メイン基板の上の面から 0.2mm あけた。下の段はメイン基板の裏の面のはんだのために足した。同じ番号の上・下のパッドは同じピン)、ピッチ 0.8mm(0.85mm では外のビアが基板の縁から 0.15mm になったため)。

**メイン基板の裏でのはんだ付け**: エンコーダ基板の内側(メイン基板の下、z 12.4〜13.6)は、x ±2.9 の幅ではマウントがない(マウントは基板の左右の端の横、|x| 3.0 より外だけ。`mechanical/motor_mount/check_t24.py` の形で確かめた)。こてはメイン基板の下の、内側から入れる

## 配線

- 信号5本: チップの面で、上の段のピン(4〜8番)の端から 45° で斜めに上へ出し、パッドの真上(上の縁から 0.55mm)のビアで裏へ移り、パッドへ
- 3V3・GND: 下の段のピン(9番、11〜13番)からビアで裏へ移り、C1(0402、裏)へ。3V3 は下の縁と右の縁に沿って、GND は 45° で斜めに上がり、下の段のパッドの下の端の下(0.35mm あけて)を横に通ってパッドへ。上の段と下の段は、それぞれのパッドの列の真ん中を通る 0.2mm の線(裏、レジストでおおう)でつなぐ
- 線は信号 0.2mm、電源 0.3mm。ビア 0.6 / 0.3mm

## 確かめたこと(2026-11-21、kicad-cli 9.0.9)

- DRC: エラー 0、つながっていないパッド 0、回路図と基板の食い違い 0(`--schematic-parity`)。警告は、確かめた環境に KiCad の標準ライブラリ(`Capacitor_SMD`)が登録されていないことによるものだけ(main の基板も同じ)。ルールは main と同じ(クリアランス 0.2mm、ビア 0.6/0.3mm、縁まで 0.2mm)
- ERC: main と同じ 10件(標準ライブラリが登録されていないことによる警告だけ)
- 機体での置き場所は `mechanical/motor_mount/check_t24.py`・`mechanical/vehicle/t24_mass.py` で確かめた

## メイン基板の側

`../KOGUMA-Mk4/KOGUMA-Mk4.pretty/ENC_Base_Edge_T24`: 切り欠きの縁(local Y = 0)の内側、**上の面と裏の面の両方**に、同じ位置にパッド7つずつ(0.5 × 0.8mm、Y 0.2〜1.0、ピッチ 0.8。裏は 2026-11-25 に足した)。上と裏の同じ番号のパッドは同じピンで、上と裏をつなぐビアは配線のときに置く。回転 0 = チップの面(縁の外)が画面の上 = 左のエンコーダ(J5、縁は機体の y +16.9)。右(J6、y −16.9)は 180°。

## まだ決めていないこと

- 面付け、はんだ付けの治具(main と同じ)
- はんだ付けのパッドの大きさ(メイン基板の側 0.5 × 0.8mm、上・裏とも)は、実物で付けてみて直す

Parts:
C1: 100n; C_0402_1005Metric
J1: MAIN_BOARD; ENC_Edge_T24
U1: MT6835; TSSOP-16_4.4x5mm_P0.65mm_Pad0.35

Connections:
+3V3: C1.1, J1.1, U1.9 (VDD)
/ENC_CAL: J1.2, U1.4 (CAL_EN)
/ENC_CS: J1.6, U1.8 (CSN)
/ENC_MISO: J1.3, U1.5 (MISO)
/ENC_MOSI: J1.4, U1.6 (MOSI)
/ENC_SCK: J1.5, U1.7 (SCK)
GND: C1.2, J1.7, U1.11 (TEST), U1.12 (VSS), U1.13 (TEST_EN)

Notes on the sheet:
KOGUMA MK4 エンコーダの基板(MT6835、5.3 × 12.3 × 0.6mm、左右で同じ基板)
モーターマウント v9 に合わせる。基板の下の辺は z 3.3(フレームから 0.3mm 浮く)。メイン基板(0.6mm)の穴(1.0 × 5.9mm)を通って 1.4mm 上に出し、 メイン基板の上で J1 のパッドを両面からはんだ付けする。チップの面はマウントの面から 0.1mm なので、チップの面の部品はマウントのくぼみ(z 3.8〜11.3)の中だけ。 J1: 2〜6(CAL、MISO、MOSI、SCK、CS)はチップの面、1・7(3.3V、GND)は裏の面。メイン基板の ENC_Base_Slot(J5・J6)と番号を合わせる。 MT6835 の中心(磁気を測る中心)は x 0(車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
TEST(11)・TEST_EN(13)は GND(データシートの図5・6)。U・V・W・A・B・Z・OUT は使わない。 CAL_EN(4): ふだんは中の 250kΩ で L。校正のときに MCU(PC15、左右共通)が H にする。 C1 は裏の面(内側は開いている)、VDD(9)・VSS(12)のビアのすぐ上に置く。TVS(データシートの推奨)は場所がないので付けない。

Board: 2 copper layers, 6.0 x 8.8 mm, 3 parts (1 on the bottom side), 7 nets.

## Code that names these connections

File docs/calc/check_pins.py:

"""MK4のピンの割り当て(docs/pinmap.md)が、STM32H562RG(VFQFPN68)で本当に使えるかを確かめる(2026-11-26 に STM32H725RG から替えた)

STの公開しているピン定義(STM32CubeMXと同じデータ)を使う:
  git clone --depth 1 https://github.com/STMicroelectronics/STM32_open_pin_data
  python3 docs/calc/check_pins.py STM32_open_pin_data/mcu/STM32H562RGVx.xml

確かめること:
  - ピンがこのパッケージにあるか
  - そのピンに、割り当てた機能(信号)があるか
  - 同じピンを2回使っていないか
  - 使っていないIOの一覧
"""
import sys
import xml.etree.ElementTree as ET
from collections import Counter

# (ピン, 信号 / 'GPIO_Output' / 'GPIO_Input' / 'RCC_OSC_IN' など, ネット名, 用途)
ASSIGN = [
    # モーター(MP6551 × 2)。IN1・IN2の両方をPWMにして、止めている側を0にする(減衰はどちらの向きも下側のFET)
    ('PA8',  'TIM1_CH1',  'MOT_L_IN1', '左モーター IN1(PWM)'),
    ('PA9',  'TIM1_CH2',  'MOT_L_IN2', '左モーター IN2(PWM)'),
    ('PA10', 'TIM1_CH3',  'MOT_R_IN1', '右モーター IN1(PWM)'),
    ('PA11', 'TIM1_CH4',  'MOT_R_IN2', '右モーター IN2(PWM)'),
    ('PB2',  'GPIO_Output', 'MOT_EN', 'ドライバ2個のEN1・EN2(共通。Lでスリープ)'),
    ('PC9',  'GPIO_Input',  'MOT_nFAULT', 'ドライバ2個のnFAULT(オープンドレインを共通に)'),
    ('PC4',  'ADC2_INP4',  'MOT_L_I', '左モーターの電流(INA241A3 の出力、2026-11-23)'),
    ('PA4',  'ADC2_INP18', 'MOT_R_I', '右モーターの電流(INA241A3 の出力、2026-11-23)'),
    ('PC5',  'ADC2_INP8',  'MOT_L_CMS', '左の MP6551 の CM1 + CM2(電池から出る電流の目安、2026-11-23)'),
    ('PA3',  'ADC2_INP15', 'MOT_R_CMS', '右の MP6551 の CM1 + CM2(電池から出る電流の目安、2026-11-23。2026-11-27 に PA5 から。PA5 を IMU の SPI1 にしたため)'),
    # エンコーダ(AS5047P × 2、SPI2。IMUのSPI3とはSPIのモードが違うのでバスを分ける)(2026-10-17)
    ('PA12', 'SPI2_SCK',  'ENC_SCK',   'エンコーダ SPIクロック'),
    ('PB14', 'SPI2_MISO', 'ENC_MISO',  'エンコーダ MISO'),
    ('PB15', 'SPI2_MOSI', 'ENC_MOSI',  'エンコーダ MOSI'),
    ('PC6',  'GPIO_Output', 'ENC_L_CS', '左エンコーダ チップセレクト'),
    ('PC7',  'GPIO_Output', 'ENC_R_CS', '右エンコーダ チップセレクト'),
    ('PC15-OSC32_OUT(OSC32_OUT)', 'GPIO_Output', 'ENC_CAL', 'エンコーダの校正(MT6835 の CAL_EN、左右共通。2026-10-29)'),
    # 壁センサ(MK3と同じ回路)
    ('PC0',  'ADC1_INP10', 'WALL_FL',  '壁センサ 左前'),
    ('PC1',  'ADC1_INP11', 'WALL_L',   '壁センサ 左'),
    ('PC2',  'ADC1_INP12', 'WALL_R',   '壁センサ 右(2026-11-27 に PA6 から。前を向いた辺のピン)'),
    ('PC3',  'ADC1_INP13', 'WALL_FR',  '壁センサ 右前(2026-11-27 に PA7 から。前を向いた辺のピン)'),
    ('PB4(NJTRST)', 'GPIO_Output', 'WALL_LED_FL_R', '壁センサの発光 FL と R(MK3 の WallLED_12)'),
    ('PB5',  'GPIO_Output', 'WALL_LED_L_FR', '壁センサの発光 L と FR(MK3 の WallLED_34)'),
    # 電源・吸引・ブザー
    ('PB1',  'ADC2_INP5', 'BATT',      '電池の電圧(分圧)'),
    ('PB8',  'TIM16_CH1', 'FAN_PWM',   '吸引ファン(PWM)'),
    ('PB0',  'ADC1_INP9', 'FAN_ISENSE', '吸引ファンの電流(シャント抵抗の電圧をRCで平均)'),
    ('PB9',  'TIM17_CH1', 'BUZZER',    'ブザー(PWM)'),
    # IMU(SPI3)
    ('PA5',  'SPI1_SCK',  'IMU_SCK',   'IMU SPIクロック(2026-11-27 に SPI3 の PC10 から SPI1 へ。IMU のほうを向いた辺のピンにして、線が MCU を回り込まないように)'),
    ('PA6',  'SPI1_MISO', 'IMU_MISO',  'IMU MISO(2026-11-27 に PC11 から)'),
    ('PA7',  'SPI1_MOSI', 'IMU_MOSI',  'IMU MOSI(2026-11-27 に PC12 から)'),
    ('PB10', 'GPIO_Output', 'IMU_CS',  'IMU チップセレクト(2026-11-27 に PA15 から)'),
    ('PB11', 'GPIO_EXTI11', 'IMU_INT', 'IMU の INT1(データ準備完了の割り込み、EXTI11。2026-11-26 に PD2 から PB3、2026-11-27 に SPI1 の近くの PB11 へ)'),
    # 通信・デバッグ
    ('PB6',  'USART1_TX', 'UART_TX',   'PCへ(USBシリアル変換)'),
    ('PB7',  'USART1_RX', 'UART_RX',   'PCから'),
    ('PA13(JTMS/SWDIO)', 'DEBUG_JTMS-SWDIO', 'SWDIO', '書き込み・デバッグ'),
    ('PA14(JTCK/SWCLK)', 'DEBUG_JTCK-SWCLK', 'SWCLK', '書き込み・デバッグ'),
    # 表示・入力
    ('PE0',  'GPIO_Output', 'LED_FRONT', '前の LED(D98。2026-10-31。2026-11-26 に PB3 から PE0 へ。PB3 を IMU_INT にしたため)'),
    ('PC8',  'GPIO_Output', 'LED_MODE0', 'モード ビット0(2026-11-27 に PA0 から。LED のある後ろを向いた辺)'),
    ('PA15(JTDI)', 'GPIO_Output', 'LED_MODE1', 'モード ビット1(2026-11-27 に PA1 から)'),
    ('PC10', 'GPIO_Output', 'LED_MODE2', 'モード ビット2(2026-11-27 に PA2 から)'),
    # 壁の表示 LED と状態の LED(2026-11-27、ユーザー: あまったピンを LED に)。壁の表示は前を向いた辺のピン
    ('PA0',  'GPIO_Output', 'LED_WALL_FL', '壁の表示 FL(D110)'),
    ('PA1',  'GPIO_Output', 'LED_WALL_L',  '壁の表示 L(D111)'),
    ('PA2',  'GPIO_Output', 'LED_WALL_R',  '壁の表示 R(D112)'),
    ('PC13', 'GPIO_Output', 'LED_WALL_FR', '壁の表示 FR(D113)。PC13 は 3mA・2MHz まで(LED は 1kΩ で約 1mA なので足りる)'),
    ('PC11', 'GPIO_Output', 'LED_STATUS0', '状態の LED 0(D114、前の LED の左)'),
    ('PC12', 'GPIO_Output', 'LED_STATUS1', '状態の LED 1(D115、前の LED の右)'),
    ('PD12', 'GPIO_Output', 'LED_NUM0',  'ナンバー ビット0(2026-11-27 に PA3 から。LED のある後ろを向いた辺のピン)'),
    ('PD11', 'GPIO_Output', 'LED_NUM1',  'ナンバー ビット1(2026-11-27 に PB10 から)'),
    ('PB12', 'GPIO_Output', 'LED_NUM2',  'ナンバー ビット2'),
    ('PB13', 'GPIO_Output', 'LED_NUM3',  'ナンバー ビット3'),
    ('PC14-OSC32_IN(OSC32_IN)', 'GPIO_Input', 'SW', 'スイッチ'),
    # 発振子(HSE)10MHz、CSTNE10M0G52A000R0(2026-10-29。MK3 と同じ仕様。2026-11-26 に Z から A へ。それまでは付けず HSI)
    ('PH0-OSC_IN(PH0)', 'RCC_OSC_IN',  'OSC_IN',  '発振子(HSE)'),
    ('PH1-OSC_OUT(PH1)', 'RCC_OSC_OUT', 'OSC_OUT', '発振子(HSE)'),
]

# タイマのエンコーダモードで読むエンコーダ(A相, B相)の組。磁気式(SPI)にしたので今はない
ENCODERS = []

def main(path):
    ns = {'m': 'http://dummy.com'}
    root = ET.parse(path).getroot()
    pins = {}
    for p in root.findall('m:Pin', ns):
        if p.get('Type') == 'I/O':
            pins[p.get('Name')] = {s.get('Name') for s in p.findall('m:Signal', ns)}
    print(f"{root.get('RefName')} ({root.get('Package')}): I/O {len(pins)}本")

    ok = True
    used = Counter(a[0] for a in ASSIGN)
    for pin, n in used.items():
        if n > 1:
            print(f'NG: {pin} を{n}回使っている')
            ok = False

    for pin, sig, net, _ in ASSIGN:
        if pin not in pins:
            print(f'NG: {pin} はこのパッケージにない ({net})')
            ok = False
            continue
        if sig.startswith('GPIO_'):
            if 'GPIO' not in pins[pin]:
                print(f'NG: {pin} はGPIOにできない ({net})')
                ok = False
        elif sig not in pins[pin]:
            print(f'NG: {pin} に {sig} がない ({net})')
            ok = False

    sig_of = {net: sig for _, sig, net, _ in ASSIGN}
    for a, b in ENCODERS:
        ta, ca = sig_of[a].split('_')
        tb, cb = sig_of[b].split('_')
        if ta != tb or {ca, cb} != {'CH1', 'CH2'}:
            print(f'NG: {a}/{b} が同じタイマのCH1/CH2になっていない ({sig_of[a]}, {sig_of[b]})')
            ok = False

    # 同じタイマのチャンネルを2つの用途で使っていないか
    tch = Counter(s for _, s, _, _ in ASSIGN if s.startswith(('TIM', 'ADC')))
    for s, n in tch.items():
        if n > 1:
            print(f'NG: {s} を{n}か所で使っている')
            ok = False

    spare = [p for p in pins if p not in used]
    print(f'使う: {len(used)}本 / 残り: {len(spare)}本')
    for p in spare:
        extra = sorted(s for s in pins[p] if s.startswith(('ADC', 'TIM')) and 'EXTI' not in s)
        print(f'  残り {p}: {" ".join(extra[:6])}')
    print('結果: OK' if ok else '結果: NGあり')
    return 0 if ok else 1

if __name__ == '__main__':
    sys.exit(main(sys.argv[1]))
