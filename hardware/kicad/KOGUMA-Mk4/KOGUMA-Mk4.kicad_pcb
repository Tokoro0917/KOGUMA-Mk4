# Repository Tokoro0917/KOGUMA-Mk4 (continued)

## KiCad design hardware/kicad/KOGUMA-Mk4/KOGUMA-Mk4.kicad_pcb (continued)

Parts:
BZ1: SMT-0540-S-R; Buzzer_PUI_SMT-0540
C90: 100n; C_0603_1608Metric
C91: 10u 10V; C_0603_1608Metric
D90: APTD1608LSECK/J4-PF (MODE0); LED_0603_1608Metric
D91: APTD1608LSECK/J4-PF (MODE1); LED_0603_1608Metric
D92: APTD1608LSECK/J4-PF (MODE2); LED_0603_1608Metric
D93: APTD1608LSECK/J4-PF (NUM0); LED_0603_1608Metric
D94: APTD1608LSECK/J4-PF (NUM1); LED_0603_1608Metric
D95: APTD1608LSECK/J4-PF (NUM2); LED_0603_1608Metric
D96: APTD1608LSECK/J4-PF (NUM3); LED_0603_1608Metric
D97: BAT54WS; D_SOD-323
D98: APTD1608LSECK/J4-PF (FRONT); LED_0603_1608Metric
J7: DEBUG (STLINK-V3MODS); PinHeader_2x03_P1.27mm_Vertical
Q90: 2N7002; SOT-23
R90, R91, R92, R93, R94, R95, R96, R99: 1k; R_0603_1608Metric
R97, R98: 10k; R_0603_1608Metric
SW2: TVAF06-A020B-R; SW_Push_Jianfu_TVAF06
TP1: UART_RX; TestPoint_Pad_D1.0mm

Connections:
+3V3: BZ1.1 (+), C91.1, D97.1 (K), J7.1, R98.1; also elsewhere on the board
BUZZER: Q90.1 (G), R97.1; also elsewhere on the board
GND: C90.2, C91.2, D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), D98.1 (K), J7.5, Q90.2 (S), R97.2, SW2.2; also elsewhere on the board
LED_FRONT: R99.1; also elsewhere on the board
LED_MODE0: R90.1; also elsewhere on the board
LED_MODE1: R91.1; also elsewhere on the board
LED_MODE2: R92.1; also elsewhere on the board
LED_NUM0: R93.1; also elsewhere on the board
LED_NUM1: R94.1; also elsewhere on the board
LED_NUM2: R95.1; also elsewhere on the board
LED_NUM3: R96.1; also elsewhere on the board
NRST: J7.3; also elsewhere on the board
unnamed: BZ1.2 (-), D97.2 (A), Q90.3 (D)
unnamed: D90.2 (A), R90.2
unnamed: D91.2 (A), R91.2
unnamed: D92.2 (A), R92.2
unnamed: D93.2 (A), R93.2
unnamed: D94.2 (A), R94.2
unnamed: D95.2 (A), R95.2
unnamed: D96.2 (A), R96.2
unnamed: D98.2 (A), R99.2
SW: C90.1, R98.2, SW2.1; also elsewhere on the board
SWCLK: J7.4; also elsewhere on the board
SWDIO: J7.6; also elsewhere on the board
UART_RX: TP1.1; also elsewhere on the board
UART_TX: J7.2; also elsewhere on the board

Notes on the sheet:
表示・入力・通信
LED: GPIO が H で点灯(MK3 と同じ)。1kΩ で 約1mA(3.3V、LED の電圧降下 約2V)。モード3ビット + ナンバー4ビット + 前の LED(D98、PB3、2026-10-31)。電源の LED は電源のシート。
ブザー: SMT-0540-S-R(定格3V)を 3.3V から 2N7002 で鳴らす(TIM17 の PWM)。 D97 はコイルの逆起電力を逃がす。
スイッチ: 10kΩ で 3.3V に上げ、押すと L(MK3 と同じ)。 C90 はチャタリングを少し減らす(約1ms)。
J7: ToraNeko.Mk3 の J6 と同じ並び(1 3.3V、2 UART_TX、3 NRST、4 SWCLK、5 GND、6 SWDIO、1.27mm 2 × 3)。 STLINK-V3MODS で書き込み・デバッグとログ(仮想COMポート)。UART_RX は TP1(使うときだけ線をつなぐ)。
SW2・BZ1 のフットプリントは KOGUMA-Mk4.pretty(gen_footprints.py、メーカーの推奨ランド)
ブザーのコンデンサ(2026-11-06): BZ1 のすぐそばに置く。D97 は BAT54WS(200mA)

Board: 2 copper layers, 158 parts (8 on the bottom side), 94 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2

## KiCad design hardware/kicad/KOGUMA-Mk4_Encoder/KOGUMA-Mk4_Encoder.kicad_pcb

File hardware/kicad/KOGUMA-Mk4_Encoder/README.md:

# KOGUMA-Mk4_Encoder(エンコーダの基板)

KiCad 9.0 で開く(`KOGUMA-Mk4_Encoder.kicad_pro`)。左右で同じ基板を2枚使う。

| ファイル | 中身 |
|---|---|
| `KOGUMA-Mk4_Encoder.kicad_sch` | 回路図: MT6835、C1(0.1µF)、J1(メイン基板へのパッド7つ) |
| `KOGUMA-Mk4_Encoder.kicad_pcb` | 基板 **v2**(2026-11-02): **6.0 × 10.3 × 0.6mm**、2層。MT6835 はチップの面(F)、C1 は裏の面(B)。パッド7つは表と裏の両方 |
| `KOGUMA-Mk4_Encoder.kicad_sym` | MT6835 の記号(KiCad の標準ライブラリにないので作った。ピンはデータシート Rev.1.3 の表) |
| `KOGUMA-Mk4_Encoder.pretty/ENC_Edge` | 基板の上の辺のパッド(表と裏)。`Dwgs.User` にメイン基板の裏、マウントのくぼみの上下、磁石の軸、下の辺を描いてある |
| `KOGUMA-Mk4_Encoder.pretty/TSSOP-16_4.4x5mm_P0.65mm_Pad0.35` | KiCad の TSSOP-16 のパッドの幅を 0.4 → 0.35mm にしたもの |
| `gen_encoder.py` | v2 を作るスクリプト。`ENC_Edge` とメイン基板の側の `ENC_Base_Butt` を書き、部品の位置・外形・配線を作り直す |
| `KOGUMA-Mk4_Encoder_v2.png` | 図(左がチップの面、右が裏の面。どちらもチップの面の側から見た向き) |

メイン基板の側のフットプリントは `../KOGUMA-Mk4/KOGUMA-Mk4.pretty/ENC_Base_Butt`(J5・J6、メイン基板の裏のパッドをエンコーダ基板の内側と外側に1列ずつ。穴はない)。番号は J1 と同じ。

## 置き方(モーターマウント v12、基板 v18、2026-11-02)

- **メイン基板(0.6mm、z 13.6〜14.2)の裏に、上の辺を突き当てて**はんだ付けする(ToraNeko.Mk3 と同じ付け方。メイン基板に穴は開けない)。机の上で治具を使って直角に付けてから、メイン基板ごとマウントに載せる
- 基板は z 3.3〜13.6(下の辺はフレームから 0.3mm 浮く)、x −3.0〜3.0(x 0 が車軸の真上)。チップの面(F)は外(磁石の側)を向き、**マウントの面(y ∓21.0)に当たる**
- MT6835 の中心は x 0、z 7.5(上の辺から 6.1mm)。IC と磁石のすき間は 0.5mm
- チップの面は、上の辺から 2.3mm(z 11.3〜13.6)がマウントの面に当たり、その下(z 3.8〜11.3)がマウントのくぼみ。チップの面の部品はくぼみの中だけ。上の 2.3mm にはパッド・ビア・線だけ
- **パッドは表と裏の両面に7つずつ**(同じ番号は同じネット)。両面でメイン基板にはんだ付けして固定する。表(チップの面)のはんだのフィレットは、マウント v12 の面の上の端の逃げ(z 12.6 より上、面から外へ 1.2mm)に入る
- 左右で同じ基板。右は 180° 回した向きで付ける(メイン基板の J6 を 180° 回して置く)

## J1(裏は上の辺から 0.2〜1.2mm、表は 0.2〜0.9mm。幅 0.5mm、0.8mm おき)

チップの面の側から見て左から:

| x | 番号 | ネット |
|---|---|---|
| −2.4 | 6 | ENC_CS |
| −1.6 | 5 | ENC_SCK |
| −0.8 | 4 | ENC_MOSI |
| 0.0 | 3 | ENC_MISO |
| 0.8 | 2 | ENC_CAL(CAL_EN) |
| 1.6 | 1 | +3V3 |
| 2.4 | 7 | GND |

表と裏で x は同じ(表も裏も、チップの面の側から見た向き)。

メイン基板の裏のパッド(`ENC_Base_Butt`)は、エンコーダ基板の内側の面から 0.3〜1.3mm(ToraNeko の TN_ENC_Base と同じ)と、外側の面から 0.3〜1.1mm(マウントの逃げの中)、幅 0.5mm。x はエンコーダ基板と逆向き(左のエンコーダ J5 では、3.3V が機体の後ろ側)。

## 回路と配線

- MT6835 は 180° 回し、SPI と CAL_EN のある辺(1〜8番)を上に向けた。5本はチップの面をまっすぐ上へ出し、上の辺から 1.85mm のビア(0.6/0.3mm)から表と裏の真上のパッドへ。3.3V・GND も同じ高さのビアで表のパッドへ
- VDD(9)・VSS(12)は IC の下の列のすぐ上のビアで裏に移り、C1(0.1µF、0402、裏の面)を通って上の 3.3V・GND のパッドへ。11・12・13 番(VSS・TEST・TEST_EN)はチップの面でつなぐ
- TEST(11)・TEST_EN(13)は GND(データシートの図5・6)。U・V・W・A・B・Z・OUT は使わない
- CAL_EN(4)は中に 250kΩ のプルダウンがあり、ふだんは L。校正のときにメイン基板の PC15 で H にする
- TVS(データシートの推奨)は場所がないので付けない

## 確かめたこと(2026-11-02、kicad-cli 9.0.9)

- ERC: エラー 0
- DRC: エラー・警告 0、つながっていないパッド 0、回路図と基板の食い違い 0。ルールは ToraNeko.Mk3 と同じ(クリアランス 0.2mm、ビア 0.6/0.3mm、穴と穴 0.25mm、縁まで 0.2mm)
- メイン基板(J5・J6 を `ENC_Base_Butt` に)も DRC で回路図との食い違い 0
- v1(2026-10-29、5.3 × 12.3mm、メイン基板の穴に通して上ではんだ付け)は git の履歴にある

## まだ決めていないこと

- 面付け(1枚が小さいので、何枚かつないで注文する。ToraNeko.Mk3 の `panel/` を参考に)
- 直角の出し方(はんだ付けのときの治具。ToraNeko の `mechanical/jigs/encoder_solder_jig/` を 6.0 × 10.3mm に合わせる)

Parts:
C1: 100n; C_0402_1005Metric
J1: MAIN_BOARD; ENC_Edge
U1: MT6835; TSSOP-16_4.4x5mm_P0.65mm_Pad0.35

Connections:
+3V3: C1.1, J1.1, U1.9 (VDD)
/ENC_CAL: J1.2, U1.4 (CAL_EN)
/ENC_CS: J1.6, U1.8 (CSN)
/ENC_MISO: J1.3, U1.5 (MISO)
/ENC_MOSI: J1.4, U1.6 (MOSI)
/ENC_SCK: J1.5, U1.7 (SCK)
GND: C1.2, J1.7, U1.11 (TEST), U1.12 (VSS), U1.13 (TEST_EN)

Notes on the sheet:
KOGUMA MK4 エンコーダの基板(MT6835、6.0 × 10.3 × 0.6mm、左右で同じ基板、v2)
モーターマウント v11・基板 v18 に合わせる(2026-11-02、v2)。基板の下の辺は z 3.3(フレームから 0.3mm 浮く)。上の辺をメイン基板(0.6mm)の裏(z 13.6)に突き当て、 J1 のパッドとメイン基板の裏のパッド(ENC_Base_Butt、J5・J6)をはんだ付けする。チップの面はマウントの面に当たるので、チップの面の部品はマウントのくぼみ(z 3.8〜11.3)の中だけ。 J1: パッド7つ(1 3.3V、2 CAL、3 MISO、4 MOSI、5 SCK、6 CS、7 GND)はすべて裏の面(内側)。チップの面の上 2.3mm はマウントの面に当たり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
TEST(11)・TEST_EN(13)は GND(データシートの図5・6)。U・V・W・A・B・Z・OUT は使わない。 CAL_EN(4): ふだんは中の 250kΩ で L。校正のときに MCU(PC15、左右共通)が H にする。 C1 は裏の面(内側は開いている)、VDD(9)・VSS(12)のビアのすぐ上に置く。TVS(データシートの推奨)は場所がないので付けない。

Board: 2 copper layers, 6.0 x 10.3 mm, 3 parts (1 on the bottom side), 7 nets.

## Code that names these connections

File docs/calc/check_pins.py:

"""MK4のピンの割り当て(docs/pinmap.md)が、STM32H725RG(VFQFPN68)で本当に使えるかを確かめる

STの公開しているピン定義(STM32CubeMXと同じデータ)を使う:
  git clone --depth 1 https://github.com/STMicroelectronics/STM32_open_pin_data
  python3 docs/calc/check_pins.py STM32_open_pin_data/mcu/STM32H725RGVx.xml

確かめること:
  - ピンがこのパッケージにあるか
  - そのピンに、割り当てた機能(信号)があるか
  - 同じピンを2回使っていないか
  - 使っていないIOの一覧
"""
import sys
import xml.etree.ElementTree as ET
from collections import Counter

# (ピン, 信号 / 'GPIO_Output' / 'GPIO_Input' / 'RCC_OSC_IN' など, ネット名, 用途)
ASSIGN = [
    # モーター(MP6551 × 2)。IN1・IN2の両方をPWMにして、止めている側を0にする(減衰はどちらの向きも下側のFET)
    ('PA8',  'TIM1_CH1',  'MOT_L_IN1', '左モーター IN1(PWM)'),
    ('PA9',  'TIM1_CH2',  'MOT_L_IN2', '左モーター IN2(PWM)'),
    ('PA10', 'TIM1_CH3',  'MOT_R_IN1', '右モーター IN1(PWM)'),
    ('PA11', 'TIM1_CH4',  'MOT_R_IN2', '右モーター IN2(PWM)'),
    ('PB2',  'GPIO_Output', 'MOT_EN', 'ドライバ2個のEN1・EN2(共通。Lでスリープ)'),
    ('PC9',  'GPIO_Input',  'MOT_nFAULT', 'ドライバ2個のnFAULT(オープンドレインを共通に)'),
    ('PC4',  'ADC2_INP4',  'MOT_L_CM1', '左モーターの電流(OUT1側の下側FET)'),
    ('PC5',  'ADC2_INP8',  'MOT_L_CM2', '左モーターの電流(OUT2側の下側FET)'),
    ('PA4',  'ADC2_INP18', 'MOT_R_CM1', '右モーターの電流(OUT1側の下側FET)'),
    ('PA5',  'ADC2_INP19', 'MOT_R_CM2', '右モーターの電流(OUT2側の下側FET)'),
    # エンコーダ(AS5047P × 2、SPI2。IMUのSPI3とはSPIのモードが違うのでバスを分ける)(2026-10-17)
    ('PA12', 'SPI2_SCK',  'ENC_SCK',   'エンコーダ SPIクロック'),
    ('PB14', 'SPI2_MISO', 'ENC_MISO',  'エンコーダ MISO'),
    ('PB15', 'SPI2_MOSI', 'ENC_MOSI',  'エンコーダ MOSI'),
    ('PC6',  'GPIO_Output', 'ENC_L_CS', '左エンコーダ チップセレクト'),
    ('PC7',  'GPIO_Output', 'ENC_R_CS', '右エンコーダ チップセレクト'),
    ('PC15-OSC32_OUT', 'GPIO_Output', 'ENC_CAL', 'エンコーダの校正(MT6835 の CAL_EN、左右共通。2026-10-29)'),
    # 壁センサ(MK3と同じ回路)
    ('PC0',  'ADC1_INP10', 'WALL_FL',  '壁センサ 左前'),
    ('PC1',  'ADC1_INP11', 'WALL_L',   '壁センサ 左'),
    ('PA6',  'ADC1_INP3',  'WALL_R',   '壁センサ 右'),
    ('PA7',  'ADC1_INP7',  'WALL_FR',  '壁センサ 右前'),
    ('PB4(NJTRST)', 'GPIO_Output', 'WALL_LED_FL_R', '壁センサの発光 FL と R(MK3 の WallLED_12)'),
    ('PB5',  'GPIO_Output', 'WALL_LED_L_FR', '壁センサの発光 L と FR(MK3 の WallLED_34)'),
    # 電源・吸引・ブザー
    ('PB1',  'ADC2_INP5', 'BATT',      '電池の電圧(分圧)'),
    ('PB8',  'TIM16_CH1', 'FAN_PWM',   '吸引ファン(PWM)'),
    ('PB0',  'ADC1_INP9', 'FAN_ISENSE', '吸引ファンの電流(シャント抵抗の電圧をRCで平均)'),
    ('PB9',  'TIM17_CH1', 'BUZZER',    'ブザー(PWM)'),
    # IMU(SPI3)
    ('PC10', 'SPI3_SCK',  'IMU_SCK',   'IMU SPIクロック'),
    ('PC11', 'SPI3_MISO', 'IMU_MISO',  'IMU MISO'),
    ('PC12', 'SPI3_MOSI', 'IMU_MOSI',  'IMU MOSI'),
    ('PA15(JTDI)', 'GPIO_Output', 'IMU_CS',  'IMU チップセレクト'),
    ('PD2',  'GPIO_EXTI2', 'IMU_INT', 'IMU の INT1(データ準備完了の割り込み、EXTI2。2026-10-31)'),
    # 通信・デバッグ
    ('PB6',  'USART1_TX', 'UART_TX',   'PCへ(USBシリアル変換)'),
    ('PB7',  'USART1_RX', 'UART_RX',   'PCから'),
    ('PA13(JTMS/SWDIO)', 'DEBUG_JTMS-SWDIO', 'SWDIO', '書き込み・デバッグ'),
    ('PA14(JTCK/SWCLK)', 'DEBUG_JTCK-SWCLK', 'SWCLK', '書き込み・デバッグ'),
    # 表示・入力
    ('PB3(JTDO/TRACESWO)', 'GPIO_Output', 'LED_FRONT', '前の LED(D98。2026-10-31)'),
    ('PA0',  'GPIO_Output', 'LED_MODE0', 'モード ビット0'),
    ('PA1',  'GPIO_Output', 'LED_MODE1', 'モード ビット1'),
    ('PA2',  'GPIO_Output', 'LED_MODE2', 'モード ビット2'),
    ('PA3',  'GPIO_Output', 'LED_NUM0',  'ナンバー ビット0'),
    ('PB10', 'GPIO_Output', 'LED_NUM1',  'ナンバー ビット1'),
    ('PB12', 'GPIO_Output', 'LED_NUM2',  'ナンバー ビット2'),
    ('PB13', 'GPIO_Output', 'LED_NUM3',  'ナンバー ビット3'),
    ('PC14-OSC32_IN', 'GPIO_Input', 'SW', 'スイッチ'),
    # 発振子(HSE)10MHz、CSTNE10M0G52Z000R0(2026-10-29。MK3 と同じ。それまでは付けず HSI)
    ('PH0-OSC_IN', 'RCC_OSC_IN',  'OSC_IN',  '発振子(HSE)'),
    ('PH1-OSC_OUT', 'RCC_OSC_OUT', 'OSC_OUT', '発振子(HSE)'),
]

# タイマのエンコーダモードで読むエンコーダ(A相, B相)の組。磁気式(SPI)にしたので今はない
ENCODERS = []

def main(path):
    ns = {'m': 'http://dummy.com'}
    root = ET.parse(path).getroot()
    pins = {}
    for p in root.findall('m:Pin', ns):
        if p.get('Type') == 'I/O':
            pins[p.get('Name')] = {s.get('Name') for s in p.findall('m:Signal', ns)}
    print(f"{root.get('RefName')} ({root.get('Package')}): I/O {len(pins)}本")

    ok = True
    used = Counter(a[0] for a in ASSIGN)
    for pin, n in used.items():
        if n > 1:
            print(f'NG: {pin} を{n}回使っている')
            ok = False

    for pin, sig, net, _ in ASSIGN:
        if pin not in pins:
            print(f'NG: {pin} はこのパッケージにない ({net})')
            ok = False
            continue
        if sig.startswith('GPIO_'):
            if 'GPIO' not in pins[pin]:
                print(f'NG: {pin} はGPIOにできない ({net})')
                ok = False
        elif sig not in pins[pin]:
            print(f'NG: {pin} に {sig} がない ({net})')
            ok = False

    sig_of = {net: sig for _, sig, net, _ in ASSIGN}
    for a, b in ENCODERS:
        ta, ca = sig_of[a].split('_')
        tb, cb = sig_of[b].split('_')
        if ta != tb or {ca, cb} != {'CH1', 'CH2'}:
            print(f'NG: {a}/{b} が同じタイマのCH1/CH2になっていない ({sig_of[a]}, {sig_of[b]})')
            ok = False

    # 同じタイマのチャンネルを2つの用途で使っていないか
    tch = Counter(s for _, s, _, _ in ASSIGN if s.startswith(('TIM', 'ADC')))
    for s, n in tch.items():
        if n > 1:
            print(f'NG: {s} を{n}か所で使っている')
            ok = False

    spare = [p for p in pins if p not in used]
    print(f'使う: {len(used)}本 / 残り: {len(spare)}本')
    for p in spare:
        extra = sorted(s for s in pins[p] if s.startswith(('ADC', 'TIM')) and 'EXTI' not in s)
        print(f'  残り {p}: {" ".join(extra[:6])}')
    print('結果: OK' if ok else '結果: NGあり')
    return 0 if ok else 1

if __name__ == '__main__':
    sys.exit(main(sys.argv[1]))
